# Keil uVision project eDMC.uvprojx, settings and files
target RTOS Blink (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTOS Test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA0 EK_TM4C129_BP1
  c include: C:\ti\TivaWare_C_Series-2.1.3.156;.\VERSION 1.0.1;..\..\LIBRARY\VERSION 1.0.1\DRIVER;C:\ti\TivaWare_C_Series-2.1.3.156\usblib;C:\ti\TivaWare_C_Series-2.1.3.156\examples\boards\ek-tm4c1294xl;..\..\LIBRARY\VERSION 1.0.1\SOFTWARE;C:\ti\TivaWare_C_Series-2.1.3.156\third_party
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group DRIVER LIB
    C:/ti/TivaWare_C_Series-2.1.3.156/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group UTILS
    C:/ti/TivaWare_C_Series-2.1.3.156/utils/: uartstdio.c ustdlib.c
  group USB
    C:/ti/TivaWare_C_Series-2.1.3.156/usblib/: usbbuffer.c usbdesc.c usbdma.c usbkeyboardmap.c usbmode.c usbringbuf.c usbtick.c usbulpi.c
    C:/ti/TivaWare_C_Series-2.1.3.156/usblib/host/: usbhaudio.c usbhhid.c usbhhidkeyboard.c usbhhidmouse.c usbhhub.c usbhmsc.c usbhostenum.c usbhscsi.c
    C:/ti/TivaWare_C_Series-2.1.3.156/usblib/device/: usbdaudio.c usbdbulk.c usbdcdc.c usbdcdesc.c usbdcomp.c usbdconfig.c usbddfu-rt.c usbdenum.c usbdhandler.c usbdhid.c usbdhidgamepad.c usbdhidkeyb.c usbdhidmouse.c usbdmsc.c
  group FATFS
    C:/ti/TivaWare_C_Series-2.1.3.156/third_party/fatfs/port/: mmc-ek-tm4c1294xl.c
    C:/ti/TivaWare_C_Series-2.1.3.156/third_party/fatfs/src/: ff.c
  group DRIVER MY
    ../../LIBRARY/VERSION 1.0.1/DRIVER/: CLK.1.0.1.c TIMER.1.0.1.c GPIO.1.0.1.c UART.1.0.1.c SSI.1.0.1.c I2C.1.0.1.c USB.1.0.1.c
    ../../LIBRARY/VERSION 1.0.1/SOFTWARE/SD CARD/: SDCARD.1.0.1.c
  group FIRMWARE
    ./VERSION 1.0.1/FIRMWARE/: MAIN.1.0.c EDMC.OS.1.0.1.c EDMC.LED.1.0.1.c EDMC.INDICATOR.1.0.1.c EDMC.KEYPAD.1.0.1.c EDMC.LCD.1.0.1.c EDMC.KEYBOARD.1.0.1.c EDMC.SDCARD.1.0.1.c EDMC.ICDI.1.0.1.c EDMC.UART.1.0.1.c EDMC.SPI.1.0.1.c EDMC.I2C.1.0.1.c EDMC.WIFI.1.0.1.c
  group CMD LINE
    ./VERSION 1.0.1/SOFTWARE/Command Line/: SW.CMD.1.0.1.c
  group SYSCTL
    ./VERSION 1.0.1/SOFTWARE/System Control/: SW.SYSCTL.1.0.1.c
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, Device:Startup 1.0.0
